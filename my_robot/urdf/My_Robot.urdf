Commit message: My_Robot_Test launch file which includes both gazebo and px4 sitl for iris

File: my_robot/urdf/My_Robot.urdf (robot description, URDF)
Before this commit: robot My_Robot, 7 links, 6 joints
Joints:
- joint base_to_fcu: origin xyz=0 0 0.26 rpy=0 0 0 -> xyz=0 0 0.26 rpy=0 1.57 0
